# Keil uVision project LCD_ENC.uvproj, settings and files
target STM32F1xx (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD_ENC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Code
    ./: STM32F10x.s LCD_ENC.asm
  group Help
    ./: ReadMe.txt
